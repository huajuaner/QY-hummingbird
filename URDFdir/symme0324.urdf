Commit message: hint240427

File: URDFdir/symme0324.urdf (robot description, URDF)
Before this commit: robot bird240324.SLDASM, 5 links, 4 joints
Links:
- link base_link: mass 0.006 -> 0.00998
